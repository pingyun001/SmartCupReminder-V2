# Keil uVision project F405_CUP_MAT_V2.uvprojx, settings and files
target F405_CUP_MAT_V2 (6220000::V6.22::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F405_CUP_MAT_V2 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,LV_LVGL_H_INCLUDE_SIMPLE,USING_LIME_HARDWARE
  c misc: -fdebug-macro
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Bsp;../FatFs;../AppLogic;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;../Lvgl/src;../Lvgl/demos;../LvglPorts;../App;../../LVGL_SIMULATION/Lime_Interface
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\F405_CUP_MAT_V2.sct
  group ConfigFiles
    ../LvglPorts/: lv_conf.h
    ../FatFs/: ffconf.h
    ../Core/Inc/: main.h
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dac.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Bsp
    ../Bsp/: spi_flash.c spi_flash_test.c ws2812.c ds18b20.c key.c lcd.c lcd_init.c esp8266.c rtc_time.c
  group FatFs
    ../FatFs/: diskio.c ff.c ffsystem.c ffunicode.c
  group Lvgl
    ../Lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Lvgl/src/display/: lv_display.c
    ../Lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Lvgl/src/layouts/flex/: lv_flex.c
    ../Lvgl/src/layouts/grid/: lv_grid.c
    ../Lvgl/src/layouts/: lv_layout.c
    ../Lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Lvgl/src/libs/bmp/: lv_bmp.c
    ../Lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
    ../Lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../Lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Lvgl/src/libs/libpng/: lv_libpng.c
    ../Lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Lvgl/src/libs/lz4/: lz4.c
    ../Lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Lvgl/src/libs/rle/: lv_rle.c
    ../Lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../Lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../Lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Lvgl/src/stdlib/: lv_mem.c
    ../Lvgl/src/themes/default/: lv_theme_default.c
    ../Lvgl/src/themes/mono/: lv_theme_mono.c
    ../Lvgl/src/themes/simple/: lv_theme_simple.c
    ../Lvgl/src/themes/: lv_theme.c
    ../Lvgl/src/tick/: lv_tick.c
    ../Lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Lvgl/src/widgets/animimage/: lv_animimage.c
    ../Lvgl/src/widgets/arc/: lv_arc.c
    ../Lvgl/src/widgets/bar/: lv_bar.c
    ../Lvgl/src/widgets/button/: lv_button.c
    ../Lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Lvgl/src/widgets/canvas/: lv_canvas.c
    ../Lvgl/src/widgets/chart/: lv_chart.c
    ../Lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Lvgl/src/widgets/image/: lv_image.c
    ../Lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Lvgl/src/widgets/label/: lv_label.c
    ../Lvgl/src/widgets/led/: lv_led.c
    ../Lvgl/src/widgets/line/: lv_line.c
    ../Lvgl/src/widgets/list/: lv_list.c
    ../Lvgl/src/widgets/lottie/: lv_lottie.c
    ../Lvgl/src/widgets/menu/: lv_menu.c
    ../Lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Lvgl/src/widgets/roller/: lv_roller.c
    ../Lvgl/src/widgets/scale/: lv_scale.c
    ../Lvgl/src/widgets/slider/: lv_slider.c
    ../Lvgl/src/widgets/span/: lv_span.c
    ../Lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Lvgl/src/widgets/spinner/: lv_spinner.c
    ../Lvgl/src/widgets/switch/: lv_switch.c
    ../Lvgl/src/widgets/table/: lv_table.c
    ../Lvgl/src/widgets/tabview/: lv_tabview.c
    ../Lvgl/src/widgets/textarea/: lv_textarea.c
    ../Lvgl/src/widgets/tileview/: lv_tileview.c
    ../Lvgl/src/widgets/win/: lv_win.c
    ../Lvgl/src/: lv_init.c
    ../Lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Lvgl/src/others/gridnav/: lv_gridnav.c
    ../Lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Lvgl/src/others/imgfont/: lv_imgfont.c
    ../Lvgl/src/others/monkey/: lv_monkey.c
    ../Lvgl/src/others/observer/: lv_observer.c
    ../Lvgl/src/others/snapshot/: lv_snapshot.c
    ../Lvgl/src/others/sysmon/: lv_sysmon.c
    ../Lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
  group LvglPorts
    ../LvglPorts/: lv_port_disp.c
  group LvglDemos
    ../Lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../Lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../Lvgl/demos/stress/: lv_demo_stress.c
    ../Lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../Lvgl/demos/widgets/: lv_demo_widgets.c
    ../Lvgl/demos/: lv_demos.c
  group LvglInterface
    ../../LVGL_SIMULATION/Lime_Interface/: Lime_App_Base.c Lime_App_Hal.c Lime_CountFace.c Lime_LvMainFace.c Lime_MessageBox.c Lime_SimFiveKey.c Lime_HeadBar.c Lime_WeatherFace.c Lime_SettingFace.c Lime_App_StartFace.c
  group LvglResources
    ../../LVGL_SIMULATION/Lime_Resources/: lime_font_main_remain.c lime_font_main_time.c lime_img_counting.c lime_img_idle.c lime_img_timeout.c lime_img_moon.c lime_img_weatherlogo.c lime_img_wificonn.c lime_img_wifidisconn.c lime_img_pos.c lime_mainbg.c Lime_MessageBox_InfoFont.c Lime_MessageBox_TitleFont.c lime_font_headbar.c lime_font_weather_title.c lime_font_weather_num.c lime_setting_about.c lime_setting_screen.c lime_setting_time.c lime_setting_voice.c lime_font_setting_title.c lime_font_setting_sub_text.c lime_setting_checked.c LR_StartFace_InfoFont.c LR_StartFace_PerFont.c
  group AppLogic
    ../AppLogic/: FatFsSelfTest.c exfuns.c file_system_logic.c stm_system_io.c audio_player.c rgbled_logic.c audio_call_logic.c
  group App
    ../App/: lvgl_main.c sensor_main.c key_main.c audio_main.c
software components: CMSIS:CORE 6.1.0
